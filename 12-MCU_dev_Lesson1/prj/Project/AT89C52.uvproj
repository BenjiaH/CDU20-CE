# Keil uVision project AT89C52.uvproj, settings and files
target AT89C52 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT89C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib\System\delay;..\Lib\System\display;..\User;..\Lib\Core
  group Core
    ../Lib/Core/: STARTUP.A51 REG52.H
  group System
    ../Lib/System/delay/: delay.c
    ../Lib/System/display/: display.c
  group User
    ../User/: main.c
  group Doc
    ../Doc/: README.txt
